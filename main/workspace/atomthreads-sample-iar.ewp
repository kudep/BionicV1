# IAR project atomthreads-sample-iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; ATOM_STACK_CHECKING
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: ..\inc\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: atomthreads-sample-iar.hex
  ILINK.IlinkOutputFile: atomthreads.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  ICCSTM8.CCDefines: NDEBUG; STM8S105
  group kernel/inc
    ../../kernel/inc/: atom.h atommutex.h atomport-template.h atomqueue.h atomsem.h atomtimer.h
  group kernel/src
    ../../kernel/src/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
  group libraries/Service/inc
    ../../libraries/Service/inc/: cmdline.h
  group libraries/Service/src
    ../../libraries/Service/src/: cmdline.c
  group libraries/STM8L152_DriverExtInterface/inc
    ../../libraries/STM8L152_DriverExtInterface/inc/: mdriver.h mtrcontroller.h sensreader.h
  group libraries/STM8L152_DriverExtInterface/src
    ../../libraries/STM8L152_DriverExtInterface/src/: mdriver.c mtrcontroller.c sensreader.c
  group libraries/STM8L152_DriverIntInterface/inc
    ../../libraries/STM8L152_DriverIntInterface/inc/: adc.h spi.h usart.h
  group libraries/STM8L152_DriverIntInterface/src
    ../../libraries/STM8L152_DriverIntInterface/src/: adc.c spi.c usart.c
  group libraries/STM8L15x_StdPeriph_Driver/inc
    ../../libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_conf.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group libraries/STM8L15x_StdPeriph_Driver/src
    ../../libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group libraries/STM8x_AtomPort/inc
    ../../libraries/STM8x_AtomPort/inc/: atomport-private.h atomport-tests.h atomport.h
  group libraries/STM8x_AtomPort/src
    ../../libraries/STM8x_AtomPort/src/: atomport-asm-iar.s atomport.c
  group main/inc
    ../inc/: configuration.h stm8l15x_it.h
  group main/src
    ../src/: main.c stm8l15x_it.c
